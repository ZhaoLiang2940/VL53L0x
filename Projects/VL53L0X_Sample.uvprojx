# Keil uVision project VL53L0X_Sample.uvprojx, settings and files
target VL53L0x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L051K8Ux STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: VL53L0X_Sample
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L051xx,USE_HAL_DRIVER
  c include: ..\HALx\Inc;..\App;..\Sys;..\Driver;..\HALx\Inc\Legacy;..\VL53L0x\App;..\VL53L0x\core\inc;..\VL53L0x\platform\inc;..\Board\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ../App/: main.c stm32l0xx_it.c DeviceAction.c stm32l0xx_hal_msp.c runStatus.c
  group HAL
    ../HALx/Src/: stm32l0xx_hal.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rcc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_pwr_ex.c
  group Board
    ../Board/src/: USART.c Button.c Board_Init.c Board_GPIO.c
  group VL53L0x_App
    ../VL53L0x/App/: VL53L0x.c VL53L0x_Cali.c VL53L0x_Gen.c
  group VL53L0x_Core
    ../VL53L0x/core/src/: VL53L0x_API.c VL53L0x_API_Calibration.c VL53L0x_API_Core.c VL53L0x_API_Ranging.c VL53L0x_API_Strings.c
  group VL53L0x_Platform
    ../VL53L0x/platform/src/: VL53L0x_I2C.c VL53L0x_platform.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
